File: TuringPanel/TuringPanel.kicad_pcb (KiCad board)
At the start: 4 copper layers, 200 x 100 mm, 24 parts

Commit message: Manufacturing Updates
Other:
- copper layers 4 -> 2
